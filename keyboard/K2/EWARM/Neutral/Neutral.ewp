# IAR project Neutral.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZE ST STM32F207ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F207xx; USE_HAL_DRIVER; NEUTRAL
  ICCARM.PreInclude: D:\Workspace\IAR\keyboard\K2\Source\Utility\preinclude.h
  ICCARM.CCIncludePath2: ..\..\Source\Lib\CMSIS; ..\..\Source\Lib\CMSIS\Device; ..\..\Source\Lib\STM32F2xx_HAL_Driver\Inc; ..\..\Source\Lib\STM32F2xx_HAL_Driver\Inc\Legacy; ..\..\Source\Bsp; D:\Workspace\IAR\keyboard\K2\Source\Utility; ..\..\Source\Lib\FatFs\src; ..\..\Source\Lib\FatFs\src\drivers; ..\..\Source\Lib\FatFs\src\option; ..\..\Source\Lib\FreeRTOS\Source; ..\..\Source\Lib\FreeRTOS\Source\include; ..\..\Source\Lib\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\Source\Lib\FreeRTOS\Source\portable\MemMang; ..\..\Source\Lib\FreeRTOS; ..\..\Source\Lib\LwIP\src\include; ..\..\Source\Lib\LwIP\src\include\lwip; ..\..\Source\Lib\LwIP\src\include\lwip\apps; ..\..\Source\Lib\LwIP\src\include\lwip\priv; ..\..\Source\Lib\LwIP\src\include\lwip\prot; ..\..\Source\Lib\LwIP\src\include\netif; ..\..\Source\Lib\LwIP\src\include\posix; ..\..\Source\Lib\LwIP\src\include\posix\sys; ..\..\Source\Lib\LwIP\system\arch; ..\..\Source\Lib\LwIP\system\OS; ..\..\Source\Lib\LwIP\system; ..\..\Source\Lib\STemWin\Config; ..\..\Source\Lib\STemWin\inc; ..\..\Source\Lib\STemWin\Lib; ..\..\Source\Lib\STemWin\OS; ..\..\Source\Lib\STemWin\Application; ..\..\Source\App; ..\..\Source\App\Misc; ..\..\Source\App\Net; ..\..\Source\App\Ptc; ..\..\Source\App\UI; ..\..\Source\App\Menu; ..\..\Source\Lib\STemWin\PNG; D:\Workspace\IAR\keyboard\K2\Source\Utility
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Source\Lib\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\Source\Lib\FreeRTOS; ..\..\Source\Lib\FreeRTOS\Source
  OBJCOPY.OOCOutputFile: K2_V2_Neutral.hex
  ILINK.IlinkOutputFile: Neutral.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../Release/: 修改记录.md
  group App
    ../../Source/App/: main.c sys_def.h system.c work.c
  group App/Menu
    ../../Source/App/Menu/: xmenu.c
  group App/Misc
    ../../Source/App/Misc/: led.c rocker.c
  group App/Net
    ../../Source/App/Net/: net.c
  group App/Ptc
    ../../Source/App/Ptc/: onvif.c panasonic.c pelco.c ptc.c samsung.c visca.c visca_if.c visca_ip.c
  group App/UI
    ../../Source/App/UI/: Arial24.c Arial28.c Arial36.c logo.c ui.c ui_framework.c
  group Bsp
    ../../Source/Bsp/: adc.c bsp.c dma.c eeprom.c ethernetif.c fsmc.c gpio.c i2c.c key.c lcd_x.c sn3731.c spi.c stm32f2xx_hal_conf.h tim.c uart.c w25qx.c
  group Lib/CMSIS
    ../../Source/Lib/CMSIS/Device/: startup_stm32f207xx.s system_stm32f2xx.c
  group Lib/EmWin
    ../../Source/Lib/STemWin/OS/: GUI_X_OS.c
    ../../Source/Lib/STemWin/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ../../Source/Lib/STemWin/Lib/: STemWin532_CM3_OS_IAR.a
  group Lib/EmWin/PNG
    ../../Source/Lib/STemWin/PNG/: adler32.c compress.c crc32.c deflate.c GUI_PNG.c IMAGE_PNG.c infback.c inffast.c inflate.c inftrees.c png.c pngerror.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngwio.c pngwrite.c pngwtran.c pngwutil.c trees.c uncompr.c zutil.c
  group Lib/FreeRTOS
    ../../Source/Lib/FreeRTOS/: cmsis_os.c
    ../../Source/Lib/FreeRTOS/Source/: croutine.c event_groups.c FreeRTOSConfig.h list.c queue.c tasks.c timers.c
    ../../Source/Lib/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Source/Lib/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Lib/LwIP/api
    ../../Source/Lib/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Lib/LwIP/arch
    ../../Source/Lib/LwIP/system/OS/: sys_arch.c
  group Lib/LwIP/core
    ../../Source/Lib/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Lib/LwIP/core/ipv4
    ../../Source/Lib/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Lib/LwIP/netif
    ../../Source/Lib/LwIP/src/netif/: ethernet.c slipif.c
  group Lib/STM32F2xx_HAL_Driver
    ../../Source/Lib/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_crc.c stm32f2xx_hal_cryp.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_eth.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_hash.c stm32f2xx_hal_hcd.c stm32f2xx_hal_i2c.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_pcd.c stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rng.c stm32f2xx_hal_spi.c stm32f2xx_hal_sram.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_fsmc.c stm32f2xx_ll_usb.c
  group Utility
    ../../Source/Utility/: packet_list.c
