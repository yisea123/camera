<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Master\Master.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Neutral\Neutral.ewp</path>
  </project>
  <batchBuild/>
</workspace>


