# IAR project HD40.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER; HD40
  ICCARM.CCIncludePath2: ..\..\Source\App; ..\..\Source\App\Osd; ..\..\Source\App\Video; ..\..\Source\Bsp; ..\..\Source\Library\CMSIS; ..\..\Source\Library\inc; ..\..\Source\Library\STM32F10x_StdPeriph_Driver\inc; ..\..\Source\Utility
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HD40.hex
  ILINK.IlinkOutputFile: HD40.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../../Source/App/: cam_ops.c eeprom.c ir_remote.c main.c ptc.c ptz.c system.c
  group App/Osd
    ../../Source/App/Osd/: menu.c menu_framework.c
  group App/Video
    ../../Source/App/Video/: sii9022.c video.c
  group Bsp
    ../../Source/Bsp/: bsp.c i2c.c isr.c port.c spi.c uart.c
  group Doc
    ../../: README.md
  group Lib
    ../../Source/Library/lib/: lib41909_1008.a libccp_1201.a libir_sony_1101.a
    ../../Source/Library/CMSIS/: startup_stm32f10x_md.s
  group Lib/STM32F10x_StdPeriph_Driver
    ../../Source/Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Utility
    ../../Source/Utility/: packet_list.c queue.c
